# Repository dwblair/omnivore

## KiCad design jt.kicad_pcb

Board: 2 copper layers, 54.7 x 43.3 mm, 11 parts (0 on the bottom side), 10 nets.

Parts:
J1: Conn_01x02_Female; Pin_Header_Straight_1x02_Pitch2.54mm
J2: Conn_01x01; Pin_Header_Straight_1x01_Pitch2.54mm
J3, J4: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm
Q1: 2N3904-AP; TO-92_Inline_Wide
Q2, Q3: Q_PMOS_GDS; TO-220-3_Vertical
R1, R2: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: VX7805; Pin_Header_Straight_1x03_Pitch2.54mm
U2: adafruit_tpl5110; Pin_Header_Straight_1x05_Pitch2.54mm

Connections:
GND: J1.2, J3.1, J4.1, Q1.1, U1.2, U2.2
unnamed: J1.1, U2.3
unnamed: J2.1, U2.5
unnamed: J3.2, Q3.2
unnamed: J4.2, Q2.2, R2.1, U1.1
unnamed: Q1.2, R1.1
unnamed: Q1.3, Q2.1, Q3.1, R2.2
unnamed: Q2.3, Q3.3
unnamed: R1.2, U2.4
unnamed: U1.3, U2.1
